# Keil uVision project led_uart_v1.uvprojx, settings and files
target led_uart_v1_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ESEL ELITTLE
  output: led_uart_v1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\common;..\source;..\app;..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../common/: system_hc32f005.c interrupts_hc32f005.c
  group source
    ../source/: main.c
  group app
    ../app/: led_driver.c
  group driver
    ../driver/src/: ddl.c sysctrl.c uart.c bt.c lpm.c gpio.c
software components: CMSIS:CORE 5.5.0
